Commit message: Add imu to aliengo

File: aliengo_description/robots/aliengo.srdf.xacro (robot description, xacro)
@@ -3,4 +3,7 @@
     <group name="base">
       <link name="trunk"/>
+    </group>
+    <group name="imu">
+      <link name="trunk_imu"/>
     </group>
     <group name="lf_leg">
